## firmware/csi_rx/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_CSI_ENABLED=y
CONFIG_ESP_CONSOLE_UART_BAUDRATE=921600
CONFIG_ESPTOOLPY_MONITOR_BAUD_921600B=y
CONFIG_LOG_DEFAULT_LEVEL_WARN=y
```
